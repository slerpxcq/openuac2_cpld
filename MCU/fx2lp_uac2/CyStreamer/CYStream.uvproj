# Keil uVision project CYStream.uvproj, settings and files
target Target 1 (MCS-51)
  device: EZ-USB FX2LP (CY7C68XXX-X) Cypress
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0xE000-0xE1FF) CLOCK(48000000) MODDP2
  output: CYStream +hex
  AfterMake: hex2bix -i -f 0xC2 -o CYStream.iic CYStream.hex
  c flags: Optimize=6
  c define: USE_EXTERNAL_CODEC
  group Source Group 1
    ./: dscr.a51 fw.c CYStream.c EZUSB.LIB USBJmpTb.a51 uac2.h isr.c gpio.h cpld.c cpld.h codec.h codec_AK4490R.c codec_AK4490R.h codec.c
